## src/modules/comp_control/Kconfig
```kconfig
menuconfig MODULES_COMP_CONTROL
 bool "Independent composite pair controller"
 default n
 depends on MODULES_COMP_ATTITUDE
```
